# Keil uVision project lab4_ex.uvprojx, settings and files
target eval_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab4_ex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c MDR32F9Qx_it.h MDR32F9Qx_it.c max7219_7seg.h max7219_7seg.c systick.h systick.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.5, Drivers:ADC 1.5, Drivers:DMA 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5

# Keil uVision project lab3_ex.uvprojx, settings and files
target eval_board (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3_ex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c MDR32F9Qx_it.h MDR32F9Qx_it.c sin.h sin.c uart_io.h uart_io.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup_MDR1986BE9x 1.3.1, Drivers:DAC 1.3.1, Drivers:DMA 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
